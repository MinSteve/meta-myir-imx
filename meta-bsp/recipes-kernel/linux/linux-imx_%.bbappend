SRC_URI += " file://0001-board-reset.patch "

